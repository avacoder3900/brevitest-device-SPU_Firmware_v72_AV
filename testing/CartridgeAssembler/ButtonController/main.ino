#include "main.h"

Button startMakingCartridge;
Button moveStageLeft, moveStageRight;
Button moveNozzleDistally, moveNozzleProximally;
Button pushAdhesive, pullAdhesive;
Button holdCard, releaseCard;
Button applyAirPressure;

Servo rotateServo, raiseServo, extendServo, tipServo;
Servo uvShutterServo;

bool button_pushed(Button &button) {
    button.reading = digitalRead(button.pin);

    if (button.reading != button.last_state) {
        button.debounce_time = millis();
    }

    if ((millis() - button.debounce_time) > DEBOUNCE_DELAY) {
        if(button.reading == LOW) {
            return true;
        }
    }

    button.last_state = button.reading;

    return false;
}

void initialize_button(Button &button, int pin) {
    button.pin = pin;
    pinMode(button.pin, button.mode);
}

void initialize_servo(Servo &servo, int pin, int init) {
    servo.attach(pin);
    servo.write(init);
}


void move_servo(Servo &servo, int toAngle, int step_delay) {
    int fromAngle = servo.read();
    if (fromAngle > toAngle) {
        for (int i = fromAngle; i >= toAngle; i--) {
            servo.write(i);
            delay(step_delay);
        }
    }
    else if (fromAngle < toAngle) {
        for (int i = fromAngle; i <= toAngle; i++) {
            servo.write(i);
            delay(step_delay);
        }
    }
}

void move_servo_fast(Servo &servo, int toAngle) {
    move_servo(servo, toAngle, 10);
}

void move_servo_slow(Servo &servo, int toAngle) {
    move_servo(servo, toAngle, 100);
}

void reset_robot_arm() {
    move_servo_fast(raiseServo, 90);
    move_servo_fast(extendServo, 80);
    move_servo_fast(rotateServo, 86);
    move_servo_fast(tipServo, 20);
}
void load_card() {
    send_message(MESSAGE_MOVE_STAGE_FAST, -50000);
    send_message(MESSAGE_MOVE_STAGE_SLOW, 250);

    move_servo_fast(extendServo, 0);
    move_servo_fast(rotateServo, 9);
    move_servo_fast(tipServo, 17);
    move_servo_fast(raiseServo, 85);
    move_servo_fast(extendServo, 75);
    delay(500);

    send_message(MESSAGE_CARD_PICKER_PULL, 1);
    delay(2000);

    move_servo_fast(extendServo, 0);
    move_servo_fast(raiseServo, 115);
    move_servo_fast(extendServo, 70);
    move_servo_fast(raiseServo, 110);
    move_servo_fast(extendServo, 80);
    move_servo_fast(raiseServo, 105);
    move_servo_fast(extendServo, 90);
    move_servo_fast(raiseServo, 90);
    move_servo_fast(extendServo, 110);
    move_servo_fast(raiseServo, 100);
    delay(500);

    send_message(MESSAGE_CARD_PICKER_PULL, 0);
    send_message(MESSAGE_CARD_PICKER_PUSH, 1);
    delay(500);

    move_servo_slow(extendServo, 105);
    move_servo_slow(raiseServo, 96);
    move_servo_slow(extendServo, 100);
    move_servo_slow(raiseServo, 92);
    move_servo_slow(extendServo, 90);
    move_servo_slow(raiseServo, 88);
    move_servo_slow(extendServo, 85);
    move_servo_slow(raiseServo, 84);
    move_servo_fast(extendServo, 80);
    move_servo_fast(raiseServo, 110);
    move_servo_fast(extendServo, 70);
    move_servo_fast(raiseServo, 115);
    move_servo_fast(extendServo, 0);

    send_message(MESSAGE_CARD_PICKER_PUSH, 0);

    move_servo_fast(raiseServo, 90);
    move_servo_fast(tipServo, 20);
    move_servo_fast(rotateServo, 86);
    move_servo_fast(extendServo, 80);
}

void openUVShutter(int duration) {
    int i;

    for(i = 1; i <= 78; i++) {
        uvShutterServo.write(i);
        delay(10);
    }

    delay(duration);

    for(i = 77; i >= 0; i--) {
        uvShutterServo.write(i);
        delay(10);
    }
}

bool send_message(int code, int param) {
    Serial1.write(START_CODE);
    Serial1.printlnf("%04d%d", code, param);
    while (!Serial1.available()) {
        Particle.process();
    }

    return (Serial1.read() == ACK_CODE);
}

void make_cartridge() {
    send_message(MESSAGE_RESET_STAGE, 0);
    send_message(MESSAGE_RESET_NOZZLE, 0);

    send_message(MESSAGE_DISPENSE_SUPPORT_DOTS, 0);

    send_message(MESSAGE_MOVE_STAGE_UNDER_UV, 0);

    openUVShutter(12000);

    send_message(MESSAGE_DISPENSE_ADHESIVE_FILL, 0);

    load_card();

    send_message(MESSAGE_MOVE_STAGE_UNDER_UV, 0);

    openUVShutter(3000);

    send_message(MESSAGE_RESET_NOZZLE, 0);
    send_message(MESSAGE_RESET_STAGE, 0);
}

void process_move_button(Button button, int startCommand) {
    if (button_pushed(button)) {
        if (send_message(startCommand, 0)) {
            while (button_pushed(button)) {
                Particle.process();
            }
            send_message(MESSAGE_STOP_STEPPER, 0);
        }
    }
}

void setup() {
    initialize_button(startMakingCartridge, A1);
    initialize_button(applyAirPressure, A2);
    initialize_button(moveStageLeft, A3);
    initialize_button(moveStageRight, A4);
    initialize_button(moveNozzleDistally, A5);
    initialize_button(moveNozzleProximally, A6);
    initialize_button(pushAdhesive, D4);
    initialize_button(pullAdhesive, D5);
    initialize_button(holdCard, D6);
    initialize_button(releaseCard, D7);

    initialize_servo(rotateServo, D0, 86);
    initialize_servo(tipServo, D1, 20);
    initialize_servo(raiseServo, D2, 90);
    initialize_servo(extendServo, D3, 80);
    initialize_servo(uvShutterServo, A0, 0);

    Serial1.begin(115200);
}

void loop() {
    process_move_button(moveStageLeft, MESSAGE_START_STAGE_LEFT);
    process_move_button(moveStageRight, MESSAGE_START_STAGE_RIGHT);
    process_move_button(moveNozzleDistally, MESSAGE_START_NOZZLE_DISTALLY);
    process_move_button(moveNozzleProximally, MESSAGE_START_NOZZLE_PROXIMALLY);

    if (button_pushed(startMakingCartridge)) {
        make_cartridge();
    }
    if (button_pushed(applyAirPressure)) {
        send_message(MESSAGE_APPLY_AIR_PRESSURE, 1000);
        delay(1000);
    }
}


